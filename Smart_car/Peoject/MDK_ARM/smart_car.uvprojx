# Keil uVision project smart_car.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\arm（compiler_5.06u7）)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart_car +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drives\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drives\STM32F1xx_HAL_Drives\Inc;..\..\Drives\CMSIS\Include;..\..\Drives;..\..\User;..\..\Drives\STM32F1xx_HAL_Drives\Src;..\..\Drives\SYSTEM;..\..\Drives\CMSIS\Device\ST\STM32F1xx\Source\Templates\arm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drives/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: stm32f1xx_it.c main.c
    ../../Drives/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Drives/BSP/: busservo.c iic.c servo.c usart.c
  group Drivers/SYSTEM
    ../../Drives/SYSTEM/delay/: delay.c
    ../../Drives/SYSTEM/sys/: sys.c
    ../../Drives/SYSTEM/usart/: usart.c
  group Drives/STM32F1xx_HAL_Drives
    ../../Drives/STM32F1xx_HAL_Drives/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_crc.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rtc.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_msp_template.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c
