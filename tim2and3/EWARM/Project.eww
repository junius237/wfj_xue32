<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\tim2and3.ewp</path>
  </project>
  <batchBuild />
</workspace>
